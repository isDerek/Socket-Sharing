# Keil uVision project Bootloader_LPC54606.uvprojx, settings and files
target Bootloader_LPC54606 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: LPC54608J512ET180:M4 NXP
  pack: Keil.LPC54000_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00028000) IRAM2(0x04000000,0x00008000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Bootloader_LPC54606.icf +hex
  AfterMake: fromelf.exe --bin -o C:\Users\Derek\Desktop\Bootloader_LPC54606\mdk\debug\Bootloader_LPC54606.bin  C:\Users\Derek\Desktop\Bootloader_LPC54606\mdk\debug\Bootloader_LPC54606.axf
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG, CPU_LPC54608, CPU_LPC54608J512ET180=1
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ../../../../../../devices/LPC54608/utilities;..\drivers;..\devices\LPC54608;..\devices\LPC54608\arm;..\devices\LPC54608;..\devices\LPC54608\drivers;..\devices\LPC54608\utilities;..\flash;..\freescaleIAP;..\crc16;.\debug;..\mdk;.\MD5
  asm define: CPU_LPC54114J256_M4, DEBUG,__CC_ARM,KEIL
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: LPC54608J512_flash.scf
  link misc: ../devices/LPC54608/arm/keil_lib_power.lib 
--remove
  group doc
    ../: readme.txt
  group startup
    ../devices/LPC54608/arm/: startup_LPC54608.s
    ../devices/LPC54608/: system_LPC54608.c system_LPC54608.h
  group drivers
    ../devices/LPC54608/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_emc.c fsl_emc.h fsl_enet.c fsl_enet.h fsl_flashiap.c fsl_flashiap.h fsl_flexcomm.c fsl_flexcomm.h fsl_gpio.c fsl_gpio.h fsl_inputmux.c fsl_inputmux.h fsl_inputmux_connections.h fsl_iocon.h fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h fsl_usart.c fsl_usart.h
  group source
    ../: Bootloader.cpp Bootloader.h flashLayout.h main.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group utilities
    ../devices/LPC54608/utilities/: fsl_debug_console.c fsl_debug_console.h
  group flash
    ../flash/: flash_api.c flash_api.h
  group FreescaleIAP
    ../freescaleIAP/: FreescaleIAP.h
  group crc16
    ../crc16/: lib_crc16.cpp lib_crc16.h
  group MD5
    ./MD5/: md5Std.cpp md5Std.h mdk_test.cpp
target gpio_led_output Release (ARM-ADS)
  device: LPC54608J512ET180:M4 NXP
  pack: Keil.LPC54000_DFP.2.2.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: gpio_led_output.out
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, CPU_LPC54608, CPU_LPC54608J512ET180=1
  c misc: as above
  c include: ../../../../../../CMSIS/Include;../../../../../../devices;../../../../../../devices/LPC54608;../../../..;..;../../../../../../devices/LPC54608/drivers;../../../../../../devices/LPC54608/utilities
  asm define: CPU_LPC54114J256_M4, NDEBUG,__CC_ARM,KEIL
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: LPC54608J512_flash.scf
  link misc: ../../../../../../devices/LPC54608/arm/keil_lib_power.lib 
--remove
